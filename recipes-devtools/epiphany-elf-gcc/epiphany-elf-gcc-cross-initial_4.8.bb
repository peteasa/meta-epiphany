##################################################################
# Part two of this refactoring will make this file an append to
# the exotic-gcc-cross-initial_4.8.bb file and the following will be
# the content of that file!
##################################################################

require epiphany-elf-gcc-cross_${PV}.bb
require epiphany-elf-gcc-cross-initial.inc
