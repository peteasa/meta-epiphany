require epiphany-elf-gcc-cross_${PV}.bb
inherit exotic-gcc-cross-initial
