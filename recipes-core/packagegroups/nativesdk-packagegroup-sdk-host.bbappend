

## add in the epiphany-sdk component
RDEPENDS_${PN} += "\
    nativesdk-epiphany-sdk \
"

