

## add in the epiphany-elf build tools
## todo for later epiphany-elf-gdb-cross-canadian-epiphany
RDEPENDS_${PN} += "\
    epiphany-elf-binutils-cross-canadian-epiphany \
    epiphany-elf-gcc-cross-canadian-epiphany \
    "

